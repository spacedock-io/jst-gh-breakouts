# Repository spacedock-io/jst-gh-breakouts

File README.md:

# JST GH breakouts

These are breakout PCBs for JST GH connectors most commonly used in drones: the 4 and 6 pin versions.

## KiCad design jst-gh-6/jst-gh-6.kicad_pcb

Parts:
H1, H2: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x06; JST_GH_SM06B-GHS-TB_1x06-1MP_P1.25mm_Horizontal
J2: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical

Connections:
unnamed: J1.1, J2.6
unnamed: J1.2, J2.5
unnamed: J1.3, J2.4
unnamed: J1.4, J2.3
unnamed: J1.5, J2.2
unnamed: J1.6, J2.1

Board: 2 copper layers, 14.1 x 26.9 mm, 4 parts (0 on the bottom side), 6 nets.

## KiCad design jst-gh-4/jst-gh-4.kicad_pcb

Board: 2 copper layers, 14.1 x 26.9 mm, 4 parts (0 on the bottom side), 4 nets.

Parts:
H1, H2: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x06; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal
J2: Conn_01x06; PinHeader_1x04_P2.54mm_Vertical

Connections:
unnamed: J1.1, J2.4
unnamed: J1.2, J2.3
unnamed: J1.3, J2.2
unnamed: J1.4, J2.1

## Commit log

2024-08-01 .gitignore
2024-08-01 Ignore Gerber outputs
2024-08-01 Add JST GH 4 and 6 pin breakouts
2024-08-02 Add a MIT license
2024-08-02 Add a README
